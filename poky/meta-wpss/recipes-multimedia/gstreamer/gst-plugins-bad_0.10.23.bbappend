EXTRA_OECONF += " --with-plugins=musicbrainz,wavpack,ivorbis,mpegvideoparse,mpegtsmux,jpegformat"
